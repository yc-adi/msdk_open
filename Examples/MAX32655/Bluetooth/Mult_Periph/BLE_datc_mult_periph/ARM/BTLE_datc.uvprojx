# Keil uVision project BTLE_datc.uvprojx, settings and files
target Flash Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MAX32655:Cortex-M4 Maxim
  pack: Maxim.MAX32655.1.0.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: BLE_datc
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BT_VER=8 INIT_BROADCASTER INIT_PERIPHERAL INIT_OBSERVER INIT_CENTRAL INIT_ENCRYPTED WSF_BUF_FREE_CHECK_ASSERT=0 WSF_BUF_STATS=0 WSF_CS_STATS=0 WSF_ASSERT_ENABLED=0 SEC_CMAC_CFG=1 SEC_ECC_CFG=2 SEC_CCM_CFG=1 HCI_TR_EXACTLE=1 WSF_TRACE_ENABLED=1 HCI_UART=2 TERMINAL_UART=0 USER_UART=1 BB_CLK_RATE_HZ=1000000 LCTR_CONN_NO_TIFS_REASSEMBLY=1 CHCI_TR_UART=1 UART_BAUD=1000000 UART_HWFC=0 BB_ENABLE_INLINE_ENC_TX=1 BB_ENABLE_INLINE_DEC_RX=1 PAL_MAX_RTC_COUNTER_VAL=0xFFFFFFFF LL_WW_RX_DEVIATION_USEC=0 BOARD=EvKit_V1 TARGET=32655 TARGET_REV=0x4131 DEBUG=1 TRACE=1  LL_DBG_PIN_ENABLED=0
  c include: ..\..\BLE_datc_mult_periph
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\BLE.sct
  group Source
    ../: main.c stack_datc.c datc_main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 1.0.0, Device:AES 1.0.0, Device:DMA 1.0.0, Device:FLC 1.0.0, Device:GPIO 1.0.0, Device:I2C 1.0.0, Device:ICC 1.0.0, Device:Low Power 1.0.0, Device:Startup 1.0.0, Device:TRNG 1.0.0, Device:Timers 1.0.0, Device:UART 1.0.0, Device:WUT 1.0.0, Bluetooth:Bluetooth LE 1.0.0
